# Keil uVision project simpleBleMulti.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: simpleBleMulti +hex
  AfterMake: fromelf -c -a -d -e -v -o simpleBleMulti.asm ./Objects/simpleBleMulti.axf
  AfterMake: fromelf.exe .\Objects\simpleBleMulti.axf --i32combined --output .\bin\simpleBleMulti.hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: OSALMEM_METRICS=0 DBG_ROM_MAIN=0 MTU_SIZE=247 DEBUG_INFO=0 _BUILD_FOR_DTM_=0 ENABLE_LOG_ROM_=0 HOST_CONFIG=0xC HCI_TL_NONE=1 OSAL_CBTIMER_NUM_TASKS=1 CFG_CP PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_NO_SLEEP MULTI_DEBUG MAX_NUM_LL_CONN=4 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1 PHY_OTA_ENABLE
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08 -DHOST_CONFIG=0xc
  c include: ..\..\..\components\inc;..\..\..\components\ble\host;..\..\..\components\ble\hci;..\..\..\components\ble\controller;..\..\..\components\ble\include;..\..\..\components\osal\include;..\..\..\components\profiles\Roles;..\..\..\components\driver\uart;..\..\..\components\profiles\DevInfo;..\..\..\components\profiles\ota;..\..\..\components\profiles\ota_app;..\..\..\components\profiles\SimpleProfile;..\..\..\components\driver\log;..\..\..\components\driver\pwrmgr;..\..\..\components\driver\uart;..\..\..\components\driver\clock;..\..\..\components\driver\gpio;..\..\..\components\driver\adc;..\..\..\components\driver\kscan;..\..\..\components\driver\flash;..\..\..\components\driver\spi;..\..\..\components\driver\i2c;..\..\..\components\driver\i2s;..\..\..\components\driver\timer;..\..\..\components\driver\watchdog;..\..\..\components\driver\kscan;..\..\..\components\libraries\crc16;..\..\..\components\arch\cm0;..\..\..\lib;..\..\..\misc;.\source\multi_role;..\..\..\components\libraries\fs;..\..\..\components\profiles\ppsp;..\..\..\components\profiles\slb;..\..\..\components\libraries\cli;..\..\..\components\libraries\ll_patch;.\source\multiRole;.\source\User
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config --info=summarystack --info=stack
  group arch
    ./: main.c
  group driver
    ../../../components/driver/clock/: clock.c
    ../../../components/driver/uart/: uart.c
    ../../../components/driver/gpio/: gpio.c
    ../../../components/driver/timer/: timer.c
    ../../../components/driver/pwrmgr/: pwrmgr.c
    ../../../components/driver/log/: my_printf.c
    ../../../components/driver/pwm/: pwm.c
    ../../../components/driver/flash/: flash.c
    ../../../components/osal/snv/: osal_snv.c
    ../../../components/driver/watchdog/: watchdog.c
    ../../../components/driver/i2c/: i2c.c
  group profile
    ../../../components/profiles/Roles/: gap.c gapbondmgr.c gapgattserver.c
    ../../../components/profiles/DevInfo/: devinfoservice.c
    ../../../components/profiles/GATT/: gattservapp.c
    ../../../components/profiles/ota_app/: ota_app_service.c
    ../../../components/profiles/ppsp/: ppsp_serv.c ppsp_impl.c
    ./source/multiRole/: multi.c multiRoleProfile.c
  group jump
    ../../../misc/: jump_table.c
  group app
    ./source/multi_role/: multi_role.c multi_role_Main.c OSAL_multi_role.c multi_timer.c multi_schedule.c
    ../../../components/profiles/slb/: slb_app.c
  group lib
    ../../../lib/: rf.lib ble_host.lib
    ../../../components/libraries/ll_patch/: ll_patch.c
  group fs
    ../../../components/libraries/fs/: fs.c fs_shadow.c fsr_raid.c
    ../../../components/libraries/cli/: cliface.c
    ../../../components/libraries/crc16/: crc16.c crc16.h
  group User
    ./source/User/: LC_Common.c LC_Event_Handler.c LC_Key.c LC_UI_led_buzzer.c LC_Uart.c LC_AES128_ECB_CBC.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
